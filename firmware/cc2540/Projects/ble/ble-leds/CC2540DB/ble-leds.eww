<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ble-leds.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ble-leds</project>
        <configuration>CC2540F128</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


